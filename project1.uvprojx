# Keil uVision project project1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x0000F800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\start;.\user;.\Library;.\Hardware;.\system
  memory RVCT4: ROM 0x8000000 size 0xF800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group library
    ./Library/: stm32f10x_wwdg.h stm32f10x_wwdg.c stm32f10x_usart.h stm32f10x_usart.c stm32f10x_tim.h stm32f10x_tim.c stm32f10x_spi.h stm32f10x_spi.c stm32f10x_sdio.h stm32f10x_sdio.c stm32f10x_rtc.h stm32f10x_rtc.c stm32f10x_rcc.h stm32f10x_rcc.c stm32f10x_pwr.h stm32f10x_pwr.c stm32f10x_iwdg.h stm32f10x_iwdg.c stm32f10x_i2c.h stm32f10x_i2c.c stm32f10x_gpio.h stm32f10x_gpio.c stm32f10x_fsmc.h stm32f10x_fsmc.c stm32f10x_flash.h stm32f10x_flash.c stm32f10x_exti.h stm32f10x_exti.c stm32f10x_dma.h stm32f10x_dma.c stm32f10x_dbgmcu.h stm32f10x_dbgmcu.c stm32f10x_dac.h stm32f10x_dac.c stm32f10x_crc.h stm32f10x_crc.c stm32f10x_cec.h stm32f10x_cec.c stm32f10x_can.h stm32f10x_can.c stm32f10x_bkp.h stm32f10x_bkp.c stm32f10x_adc.h stm32f10x_adc.c misc.h misc.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h LED.c LED.h board_config.h buzzer.c buzzer.h limit.c limit.h key_scan.c key_scan.h soft_i2c.c soft_i2c.h wf5805f.c wf5805f.h error_code.h error_manager.c error_manager.h water_depth.c water_depth.h stepper_um244.c stepper_um244.h position_tracker.c position_tracker.h homing.c homing.h crc16.c crc16.h param_store.c param_store.h ui_pages.c nap_scheduler.c auto_control.c auto_control.h self_test.c app_state.c menu.c
  group user
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
